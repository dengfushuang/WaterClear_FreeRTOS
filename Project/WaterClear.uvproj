# Keil uVision project WaterClear.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HR8P506FHLP HR
  cpu: IRAM(0x20000000-0x20001FFF)  IROM(0x00000000-0x00008FFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: WaterClear +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\CMSIS;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable;..\Hardware\Flow;..\Hardware\GSM;..\Hardware\Pressure;..\Hardware\TDS;..\Hardware\Uart;..\Library\Include;..\StartUp;..\User
  memory RVCT4: ROM 0x0 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../CMSIS/: system_HR8P506.c
  group LIB
    ../Library/Source/: hr8p506_iap_table.c lib_flashiap.c lib_gpio.c lib_scs.c lib_scu.c lib_timer.c lib_uart.c lib_wdt.c
  group StartUp
    ../StartUp/: startup_HR8P506.s
  group USER
    ../User/: main.c msgbuild.c my_systick.c
  group HARDWARE
    ../Hardware/Flow/: water_flow.c
    ../Hardware/GSM/: sim800c.c
    ../Hardware/TDS/: tds.c
    ../Hardware/Uart/: uart.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c heap_1.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/: port.c
